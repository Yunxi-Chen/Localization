options:
  parameters:
    generate_options: no_gui
    generator_class_name: PythonNoGuiGenerator
    generator_module: gnuradio.grc.workflows.python_nogui
    id: wavefom_generator
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: file_path_1
  id: variable
  parameters:
    value: '"/home/marco/Downloads/Localization/my_5g_prs_mu1_nID100_30.72M_Simplified.bin"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 122.88e6
  states: {}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'False'
    extra_dict: pmt.make_dict()
    file: /dev/shm/ch0.bin
    max_seg_size: '400000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_file_meta_sink_1
  id: blocks_file_meta_sink
  parameters:
    detached: 'False'
    extra_dict: pmt.make_dict()
    file: /dev/shm/ch1.bin
    max_seg_size: '400000000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/marco/Downloads/Localization/tx_waveform/ch0_mu=2.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/marco/Downloads/Localization/tx_waveform/ch1_mu=2.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/marco/Downloads/Localization/tx_waveform/ch2_mu=2.bin
    type: complex
  states: {}
- name: blocks_file_sink_0_0_1
  id: blocks_file_sink
  parameters:
    file: /home/marco/Downloads/Localization/tx_waveform/ch3_mu=2.bin
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '122880000'
    type: complex
  states: {}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    num_items: '122880000'
    type: complex
  states: {}
- name: blocks_head_0_0_0
  id: blocks_head
  parameters:
    num_items: '122880000'
    type: complex
  states: {}
- name: blocks_head_0_1
  id: blocks_head
  parameters:
    num_items: '122880000'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_0_0_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import os

      class blk(gr.sync_block):
          def __init__(self, 
                       file_path_1="/home/marco/Downloads/my_5g_prs_mu2_nID100.bin",
                       file_path_2="/home/marco/Downloads/my_5g_prs_mu2_nID200.bin",
                       file_path_3="/home/marco/Downloads/my_5g_prs_mu2_nID300.bin",
                       file_path_4="/home/marco/Downloads/my_5g_prs_mu2_nID400.bin",
                       samp_rate=122.88e6): # Added parameter for easy modification in GRC
              """
              Custom block to implement 5G 4-Channel PRS TDM + CDM.
              Expanded to 4 output ports for dual-USRP (4 TX) transmission.
              """
              gr.sync_block.__init__(
                  self,
                  name='5G 4-Ch MIMO PRS Muting',
                  in_sig=None,
                  out_sig=[np.complex64, np.complex64, np.complex64, np.complex64]
              )
              
              self.samp_rate = samp_rate
              
              # CORRECTED: Define the exact length of ONE slot for mu=2 (0.25 ms)
              self.slot_len = int(self.samp_rate * 0.00025) 
              
              # 1. Load the data dynamically
              def load_file(path):
                  if os.path.exists(path):
                      data = np.fromfile(path, dtype=np.complex64)
                      # CORRECTED: Use dynamic samp_rate for accurate logging
                      duration = len(data) / self.samp_rate
                      print(f"[PRS Muting] Loaded {len(data)} samples ({duration:.4f} seconds) from {os.path.basename(path)}")
                      return data
                  else:
                      print(f"[PRS Muting] ERROR: File {path} not found!")
                      return np.array([], dtype=np.complex64)

              raw_prs_1 = load_file(file_path_1)
              raw_prs_2 = load_file(file_path_2)
              raw_prs_3 = load_file(file_path_3)
              raw_prs_4 = load_file(file_path_4)
                  
              # Set the frame length to the maximum length of all files
              self.frame_len = max(len(raw_prs_1), len(raw_prs_2), len(raw_prs_3), len(raw_prs_4))
              if self.frame_len == 0:
                  self.frame_len = 1024 # Fallback to prevent crash if files are missing
                  
              # Pad arrays to equal length just in case they differ
              self.raw_prs_1 = np.pad(raw_prs_1, (0, self.frame_len - len(raw_prs_1)))
              self.raw_prs_2 = np.pad(raw_prs_2, (0, self.frame_len - len(raw_prs_2)))
              self.raw_prs_3 = np.pad(raw_prs_3, (0, self.frame_len - len(raw_prs_3)))
              self.raw_prs_4 = np.pad(raw_prs_4, (0, self.frame_len - len(raw_prs_4)))
              
              # ---------------------------------------------------------------------
              # 2. ABSOLUTE ZERO MUTING INITIALIZATION (METHOD 3)
              # ---------------------------------------------------------------------
              print("[PRS Muting] Initializing Absolute Zero Background for 4 Channels...")
              
              self.ch0_data = np.zeros(self.frame_len, dtype=np.complex64)
              self.ch1_data = np.zeros(self.frame_len, dtype=np.complex64)
              self.ch2_data = np.zeros(self.frame_len, dtype=np.complex64)
              self.ch3_data = np.zeros(self.frame_len, dtype=np.complex64)
              
              # ---------------------------------------------------------------------
              # 3. Apply the 4-Slot Masking Pattern across the ENTIRE file
              # ---------------------------------------------------------------------
              print("[PRS Muting] Applying 4-Channel TDM slot masking pattern...")
              num_slots = int(np.ceil(self.frame_len / self.slot_len))
              for i in range(num_slots):
                  start_idx = i * self.slot_len
                  end_idx = min((i + 1) * self.slot_len, self.frame_len)
                  
                  pattern_idx = i % 4
                  if pattern_idx == 0:
                      self.ch0_data[start_idx:end_idx] = self.raw_prs_1[start_idx:end_idx]
                  elif pattern_idx == 1:
                      self.ch1_data[start_idx:end_idx] = self.raw_prs_2[start_idx:end_idx]
                  elif pattern_idx == 2:
                      self.ch2_data[start_idx:end_idx] = self.raw_prs_3[start_idx:end_idx]
                  elif pattern_idx == 3:
                      self.ch3_data[start_idx:end_idx] = self.raw_prs_4[start_idx:end_idx]
                  
              self.sample_idx = 0
              print("[PRS Muting] Initialization Complete. Ready to transmit 4 channels.")

          def work(self, input_items, output_items):
              out0 = output_items[0]
              out1 = output_items[1]
              out2 = output_items[2]
              out3 = output_items[3]
              n = len(out0)
              
              idx = 0
              while idx < n:
                  current_pos = self.sample_idx % self.frame_len
                  chunk = min(n - idx, self.frame_len - current_pos)
                  
                  # Ultra-fast memory slicing for all 4 output channels
                  out0[idx : idx+chunk] = self.ch0_data[current_pos : current_pos+chunk]
                  out1[idx : idx+chunk] = self.ch1_data[current_pos : current_pos+chunk]
                  out2[idx : idx+chunk] = self.ch2_data[current_pos : current_pos+chunk]
                  out3[idx : idx+chunk] = self.ch3_data[current_pos : current_pos+chunk]
                  
                  self.sample_idx += chunk
                  idx += chunk
                  
              return n
    file_path_1: '"/home/marco/Downloads/Localization/my_5g_prs_mu1_nID100_1s_122.88M.bin"'
    file_path_2: '"/home/marco/Downloads/Localization/my_5g_prs_mu1_nID200_1s_122.88M.bin"'
    file_path_3: '"/home/marco/Downloads/Localization/my_5g_prs_mu1_nID300_1s_122.88M.bin"'
    file_path_4: '"/home/marco/Downloads/Localization/my_5g_prs_mu1_nID400_1s_122.88M.bin"'
    samp_rate: 122.88e6
  states: {}

connections:
- [blocks_head_0, '0', blocks_file_meta_sink_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_head_0_0, '0', blocks_file_meta_sink_1, '0']
- [blocks_head_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_head_0_0_0, '0', blocks_file_sink_0_0_1, '0']
- [blocks_head_0_1, '0', blocks_file_sink_0_0_0, '0']
- [blocks_throttle2_0, '0', blocks_head_0, '0']
- [blocks_throttle2_0_0, '0', blocks_head_0_0, '0']
- [blocks_throttle2_0_0_0, '0', blocks_head_0_1, '0']
- [blocks_throttle2_0_0_1, '0', blocks_head_0_0_0, '0']
- [epy_block_0, '0', blocks_throttle2_0, '0']
- [epy_block_0, '1', blocks_throttle2_0_0, '0']
- [epy_block_0, '2', blocks_throttle2_0_0_0, '0']
- [epy_block_0, '3', blocks_throttle2_0_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
